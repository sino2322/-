# Keil uVision project servo.uvproj, settings and files
target servo (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: servo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LIB\INC;.\USRLIB\INC;.\USR;.\USR\INC
  asm include: .\LIB
  group usr
    ./USR/: main.c schedule.c
  group lib
    ./LIB/: STARTUP.A51
  group usrlib
    ./USRLIB/: delay.c servo.c Interpolation.c key.c LCD.c LED.c
